# Keil uVision project STM32H7_W25QXX.uvprojx, settings and files
target STM32H7_W25QXX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L431_W25Q64
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\MPU;.\HARDWARE\QSPI;.\SYSTEM;.\HARDWARE\W25QXX;..\QSIP_W25QXX_Template-H7;..\W25Q128_QSPI_Keil烧写算法
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Hardwere
    ./HARDWARE/QSPI/: qspi.c
    ./HARDWARE/W25QXX/: norflash.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
