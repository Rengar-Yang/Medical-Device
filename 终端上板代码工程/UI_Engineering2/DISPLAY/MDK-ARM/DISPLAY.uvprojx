# Keil uVision project DISPLAY.uvprojx, settings and files
target DISPLAY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L431RBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: DISPLAY +hex
  AfterMake: srec_cat.exe @splitHex1.cmd
  AfterMake: srec_cat.exe @splitHex2.cmd
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/LCD;../Drivers/ST7789;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/Norflash;../Drivers/NS2009;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\DISPLAY.sct
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Drivers/ST7789/: st7789.c
    ../Drivers/Norflash/: norflash.c qspi.c
    ../Drivers/NS2009/: ns2009.c
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/debugwindow_screen/: debugwindowpresenter.cpp debugwindowview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/image_screen/: imagepresenter.cpp imageview.cpp
    ../touchgfx/gui/src/info_screen/: infoview.cpp
    ../touchgfx/gui/src/containers/: languageselectorelement.cpp languageselectorelementcenter.cpp netselectorelement.cpp netselectorelementcenter.cpp networklist.cpp notification.cpp
    ../touchgfx/gui/src/list_screen/: listpresenter.cpp listview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/networkmenu_screen/: networkmenupresenter.cpp networkmenuview.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_amiri_regular_18_2bpp_0.cpp font_amiri_regular_18_2bpp_31.cpp font_amiri_regular_22_4bpp_0.cpp font_chinese_msyh_10_4bpp_0.cpp font_chinese_msyh_10_4bpp_11.cpp font_chinese_msyh_10_4bpp_12.cpp font_chinese_msyh_10_4bpp_13.cpp font_chinese_msyh_10_4bpp_14.cpp font_chinese_msyh_10_4bpp_15.cpp font_chinese_msyh_10_4bpp_17.cpp font_chinese_msyh_10_4bpp_18.cpp font_chinese_msyh_10_4bpp_19.cpp font_chinese_msyh_10_4bpp_9.cpp font_chinese_msyh_14_4bpp_0.cpp font_chinese_msyh_14_4bpp_12.cpp font_chinese_msyh_14_4bpp_14.cpp font_chinese_msyh_14_4bpp_17.cpp font_chinese_msyh_14_4bpp_6.cpp font_chinese_msyh_14_4bpp_9.cpp font_chinese_msyh_20_4bpp_0.cpp font_chinese_msyh_20_4bpp_10.cpp font_chinese_msyh_20_4bpp_11.cpp font_chinese_msyh_20_4bpp_12.cpp font_chinese_msyh_20_4bpp_13.cpp font_chinese_msyh_20_4bpp_14.cpp font_chinese_msyh_20_4bpp_15.cpp font_chinese_msyh_20_4bpp_16.cpp font_chinese_msyh_20_4bpp_17.cpp font_chinese_msyh_20_4bpp_18.cpp font_chinese_msyh_20_4bpp_31.cpp font_chinese_msyh_20_4bpp_4.cpp font_chinese_msyh_20_4bpp_6.cpp font_nanumgothic_14_4bpp_0.cpp font_nanumgothic_14_4bpp_21.cpp font_nanumgothic_14_4bpp_24.cpp font_nanumgothic_14_4bpp_25.cpp font_nanumgothic_14_4bpp_26.cpp font_nanumgothic_20_4bpp_0.cpp font_nanumgothic_20_4bpp_22.cpp font_nanumgothic_20_4bpp_23.cpp font_nanumgothic_20_4bpp_24.cpp font_nanumgothic_20_4bpp_26.cpp font_nanumgothic_30_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_amiri_regular_18_2bpp.cpp kerning_amiri_regular_22_4bpp.cpp kerning_chinese_msyh_10_4bpp.cpp kerning_chinese_msyh_14_4bpp.cpp kerning_chinese_msyh_20_4bpp.cpp kerning_nanumgothic_14_4bpp.cpp kerning_nanumgothic_20_4bpp.cpp kerning_nanumgothic_30_4bpp.cpp table_amiri_regular_18_2bpp.cpp table_amiri_regular_22_4bpp.cpp table_chinese_msyh_10_4bpp.cpp table_chinese_msyh_14_4bpp.cpp table_chinese_msyh_20_4bpp.cpp table_nanumgothic_14_4bpp.cpp table_nanumgothic_20_4bpp.cpp table_nanumgothic_30_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_close.cpp image_ecg.cpp image_goback.cpp image_image0.cpp image_image01.cpp image_image02.cpp image_infobackground.cpp image_infobackground2.cpp image_joystick_overlay.cpp image_leftarrow.cpp image_leftarrowdark.cpp image_listbackground.cpp image_logo_01.cpp image_logo_01_transparent.cpp image_logotext.cpp image_logox.cpp image_networkdebug.cpp image_networktitle.cpp image_open.cpp image_pause.cpp image_rightarrow.cpp image_rightarrowdark.cpp image_subdemoicon_health.cpp image_subdemoicon_image.cpp image_subdemoicon_list.cpp image_subtitle.cpp image_tiledbackground.cpp
    ../touchgfx/generated/gui_generated/src/debugwindow_screen/: debugwindowviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_buttons_round_small.cpp image_blue_buttons_round_small_pressed.cpp
    ../touchgfx/generated/images/src/flags/: image_china-flag-small.cpp image_denmark-flag-small.cpp image_france-flag-small.cpp image_japan-flag-small.cpp image_south-korea-flag-small.cpp image_tunisia-flag-small.cpp image_united-kingdom-flag-small.cpp
    ../touchgfx/generated/images/src/networkicon/: image_networktime.cpp image_networktimebig.cpp image_update.cpp image_updatebig.cpp image_wifi.cpp image_wifibig.cpp
    ../touchgfx/generated/gui_generated/src/image_screen/: imageviewbase.cpp
    ../touchgfx/generated/texts/src/: languagecn.cpp languagedk.cpp languagefr.cpp languagegb.cpp languagejp.cpp languagekr.cpp languagetn.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: languageselectorelementbase.cpp languageselectorelementcenterbase.cpp netselectorelementbase.cpp netselectorelementcenterbase.cpp networklistbase.cpp notificationbase.cpp
    ../touchgfx/generated/gui_generated/src/list_screen/: listviewbase.cpp
    ../touchgfx/generated/gui_generated/src/networkmenu_screen/: networkmenuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 5.5.0
